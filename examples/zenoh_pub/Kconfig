## examples/zenoh_pub/Kconfig
```kconfig
config EXAMPLES_ZENOH_PUB
    bool "Zenoh publisher example"
    default n
    ---help---
    Enable the \"zenoh publisher\" example
```
